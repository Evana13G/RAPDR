Commit message: Changed name of initialization files

File: models/block/model.urdf (robot description, URDF)
Before this commit: robot block, 1 links, 0 joints
Links:
- link block: mass 20 -> 1
